## package/python-scons/Config.in.host
```kconfig
config BR2_PACKAGE_HOST_PYTHON_SCONS
	bool "host python-scons"
	help
	  SCons 4.1.0
```
